# Keil uVision project Project.uvprojx, settings and files
target System (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: System +hex
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\SourceFile\System\Trace;..\SourceFile\System\OS.Port;..\SourceFile\System\OS.Config;..\SourceFile\System\Device\Driver;..\SoureFile\System\Device;..\SoureFile\System\Device\Driver;..\SoureFile\System\CanFestival-3\drivers\STM32;..\SoureFile\System\CanFestival-3\include;..\SoureFile\System\CanFestival-3\include\STM32;..\SoureFile\System\Trace;..\SoureFile\System\CANOpenMaster;..\SoureFile\App;..\SoureFile\System\Device\Driver\StdLib\inc;..\SoureFile\System\Device\Driver\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group System.Core
    ../SoureFile/App/: main.c GlobalVar.c
  group System.Canfestval
    ../SoureFile/System/CanFestival-3/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
  group System.CANOpenDriver
    ../SoureFile/System/CanFestival-3/drivers/STM32/: can_stm32.c timer_stm32.c
  group System.CANOpenMaster
    ../SoureFile/System/CANOpenMaster/: CANOpenObjDictConfig.c
  group System.CANOpenObjectDictionary
    ../SoureFile/System/CanFestival-3/objdict/: ObjDict.c
  group System.Device
    ../SoureFile/System/Device/: device_dio.c
  group System.StdPeriphDriver
    ../SoureFile/System/Device/Driver/StdLib/src/: misc.c stm32f4xx_can.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_tim.c
  group System.Driver
    ../SoureFile/System/Device/Driver/: stm32f4xx_it.c
  group System.Trace
    ../SoureFile/System/Trace/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group System.Startup
    ../SoureFile/System/Device/Driver/CMSIS/Startup/: startup_stm32f40_41xxx.s
  group System.CMSIS
    ../SoureFile/System/Device/Driver/CMSIS/: system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
